# Keil uVision project RTOSDemo.uvprojx, settings and files
target FreeRTOS (6190000::V6.19::ARMCLANG)
  device: NUC472HI8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: RTOSDemo +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=3
  c define: RVDS_ARMCM4_NUC4xx
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\Device\Nuvoton\NUC472_442\Include;..\..\..\ThirdParty\FreeRTOSV8.2.1\FreeRTOS\SOURCE\include;..\..\..\ThirdParty\FreeRTOSV8.2.1\FreeRTOS\Demo\COMMON\include;..\..\..\ThirdParty\FreeRTOSV8.2.1\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\..\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group System
    ../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    ../../../Library/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
  group Demo Files
    ../: main.c ParTest.c
    ../../../ThirdParty/FreeRTOSV8.2.1/FreeRTOS/Demo/Common/Minimal/: QueueSet.c PollQ.c flash.c
  group FreeRTOS files
    ../../../ThirdParty/FreeRTOSV8.2.1/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/FreeRTOSV8.2.1/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../ThirdParty/FreeRTOSV8.2.1/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group lib
    ../../../Library/StdDriver/src/: retarget.c sys.c uart.c clk.c
