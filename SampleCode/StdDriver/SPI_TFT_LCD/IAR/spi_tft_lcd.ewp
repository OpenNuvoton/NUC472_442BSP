# IAR project spi_tft_lcd.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC400AE series Nuvoton NUC400AE series (NUC442AE,NUC472AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: spi_tft_lcd.bin
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/IAR/: startup_NUC472_442.s
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c spi.c sys.c timer.c uart.c
  group User
    ../: image.c main.c
