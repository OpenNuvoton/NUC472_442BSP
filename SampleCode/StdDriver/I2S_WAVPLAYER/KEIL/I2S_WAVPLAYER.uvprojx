# Keil uVision project I2S_WAVPLAYER.uvprojx, settings and files
target I2S_WAVPlayer (6190000::V6.19::ARMCLANG)
  device: NUC472HI8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: I2S
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\UsbHostLib\INCLUDE;..\..\..\..\Library\UsbHostLib\INCLUDE\inc_mass;..\..\..\..\ThirdParty\FATFS\src
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_NUC472_442.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
  group Source
    ../: main.c nuc472_442_isr.c diskio.c wavplayer.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c i2s.c i2c.c clk.c uart.c retarget.c gpio.c pdma.c
  group FATFS
    ../../../../ThirdParty/FATFS/src/: ff.c
  group USBH_Core_Lib
    ../../../../Library/UsbHostLib/SOURCE/Core/: usbh_support.c usbh_core.c usbh_debug.c usbh_hub.c usbh_ohci.c
  group USBH_MASS_Lib
    ../../../../Library/UsbHostLib/SOURCE/MassStor/: UmasTransport.c Umas_FATFS.c UmasDebug.c UmasDriver.c UmasProtocol.c
