<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\fmc_multi_word_prog.ewp</path>
  </project>
  <batchBuild/>
</workspace>


