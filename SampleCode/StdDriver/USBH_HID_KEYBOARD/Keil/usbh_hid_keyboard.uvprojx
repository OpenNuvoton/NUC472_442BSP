# Keil uVision project usbh_hid_keyboard.uvprojx, settings and files
target usbh_hid_keyboard (6150000::V6.15::ARMCLANG)
  device: NUC472HI8AE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: usbh_hid_keyboard
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\UsbHostLib\Include;..\..\..\..\ThirdParty\FATFS\src
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_NUC472_442.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c
  group User
    ../: main.c usbh_hid_kbd.c
  group USBH_Core_Lib
    ../../../../Library/UsbHostLib/Source/Core/: usbh_core.c usbh_debug.c usbh_hub.c usbh_ohci.c usbh_support.c
  group USBH_HID_Lib
    ../../../../Library/UsbHostLib/SOURCE/HID/: hid_core.c hid_driver.c
