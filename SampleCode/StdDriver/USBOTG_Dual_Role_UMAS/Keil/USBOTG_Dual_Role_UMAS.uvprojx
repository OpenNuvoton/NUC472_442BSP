# Keil uVision project USBOTG_Dual_Role_UMAS.uvprojx, settings and files
target OTG_Dual_Role_UMAS (6190000::V6.19::ARMCLANG)
  device: NUC472HI8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: OTG_Dual_Role_UMAS
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\UsbHostLib\Include;..\..\..\..\Library\UsbHostLib\Include\inc_mass;..\..\..\..\ThirdParty\FATFS\src
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_NUC472_442.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
  group User
    ../: main.c diskio.c descriptors.c MassStorage.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c clk.c usbd.c uart.c retarget.c
  group FATFS
    ../../../../ThirdParty/FATFS/src/: ff.c
  group USBH_Core_Lib
    ../../../../Library/UsbHostLib/Source/Core/: usbh_core.c usbh_debug.c usbh_hub.c usbh_ohci.c usbh_support.c
  group USBH_MASS_Lib
    ../../../../Library/UsbHostLib/Source/MassStor/: Umas_FATFS.c UmasDebug.c UmasDriver.c UmasProtocol.c UmasTransport.c
