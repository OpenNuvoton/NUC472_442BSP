# Keil uVision project EMAC_uIP_telnetd.uvproj, settings and files
target EMAC_uIP_telnetd (ARM-ADS)
  device: NUC472HI8AE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: emac
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c misc: --diag_suppress=177
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include;..\..\..\..\Library\StdDriver\inc;..\;..\..\..\..\ThirdParty\uip-0.9\uip
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_NUC472_442.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c emac.c clk.c sys.c uart.c timer.c
  group User
    ../: main.c memb.c telnetd.c telnetd-shell.c uip_arch.c
  group uIP
    ../../../../ThirdParty/uip-0.9/uip/: uip.c uip_arp.c
