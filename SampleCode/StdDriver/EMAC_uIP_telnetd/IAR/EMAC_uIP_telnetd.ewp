# IAR project EMAC_uIP_telnetd.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC400AE series Nuvoton NUC400AE series (NUC442AE,NUC472AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include; ..\..\..\..\Library\StdDriver\inc; ..; ..\..\..\..\ThirdParty\uip-0.9\uip
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EMAC_uIP_telnetd.bin
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/IAR/: startup_NUC472_442.s
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c emac.c retarget.c sys.c timer.c uart.c
  group uIP
    ../../../../ThirdParty/uip-0.9/uip/: uip.c uip_arp.c
  group User
    ../: main.c memb.c telnetd-shell.c telnetd.c uip_arch.c
