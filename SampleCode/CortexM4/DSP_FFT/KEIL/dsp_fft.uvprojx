# Keil uVision project dsp_fft.uvprojx, settings and files
target dsp_fft (6190000::V6.19::ARMCLANG)
  device: NUC472HI8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: dsp_fft
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ARM_MATH_CM4=1, __FPU_PRESENT=1
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_NUC472_442.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
  group User
    ../: main.c
    ../../../../Library/CMSIS/DSP_Lib/Examples/arm_fft_bin_example/ARM/: arm_fft_bin_data.c
  group Library
    ../../../../Library/StdDriver/src/: fmc.c retarget.c uart.c clk.c sys.c
    ../../../../Library/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
