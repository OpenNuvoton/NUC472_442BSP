# Keil uVision project ISP_SPI.uvprojx, settings and files
target ISP_SPI (6190000::V6.19::ARMCLANG)
  device: NUC472HI8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: NUC472_442_ISP_SPI
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: TARGET_NUC472_442
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_NUC472_442.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    ../../../../Library/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
  group User
    ../: main.c fmc_user.c isp_user.c targetdev.c spi_transfer.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c gpio.c spi.c sys.c timer.c uart.c
