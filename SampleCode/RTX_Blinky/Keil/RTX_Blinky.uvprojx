# Keil uVision project RTX_Blinky.uvprojx, settings and files
target RTX_Blinky (6190000::V6.19::ARMCLANG)
  device: NUC472HI8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: RTX_Blinky
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\NUC472_442\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\CMSIS\RTOS\RTX\INC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
  group StartUp
    ../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    ../../../Library/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
  group User
    ../: Blinky.c LED.c
  group Library
    ../../../Library/StdDriver/src/: clk.c sys.c uart.c retarget.c
  group RTX Configuration
    ../: RTX_Conf_CM.c
    ../../../Library/CMSIS/RTOS/RTX/LIB/ARM/: RTX_CM4.lib
  group Documentation
    ../: Abstract.txt
