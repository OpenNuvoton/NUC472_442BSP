# Keil uVision project FreeRTOS_lwIP_TCP_EchoServer.uvprojx, settings and files
target FreeRTOS_TCP_EchoServer (6190000::V6.19::ARMCLANG)
  device: NUC472HI8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: RTOS_TCP_EchoServer +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=3
  c define: RVDS_ARMCM4_NUC4xx
  c include: ..\..\..\ThirdParty\FreeRTOSV8.2.1\FreeRTOS\SOURCE\include;..\..\..\Library\Device\Nuvoton\NUC472_442\Include;..\..\..\Library\StdDriver\inc;..\..\..\ThirdParty\FreeRTOSV8.2.1\FreeRTOS\DEMO\COMMON\include;..\..\..\ThirdParty\FreeRTOSV8.2.1\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\;..\..\..\ThirdParty\lwip-1.4.1\src\include;..\..\..\ThirdParty\lwip-1.4.1\src\include\ipv4;..\lwip-1.4.1\port\FreeRTOS\include;..\lwip-1.4.1\port\FreeRTOS\include\arch;..\lwip-1.4.1\port\FreeRTOS\include\lwip;..\lwip-1.4.1\port\FreeRTOS\include\netif;..\..\..\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    ../../../Library/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
  group User
    ../: main.c tcp_echoserver-netconn.c
  group FreeRTOS
    ../../../ThirdParty/FreeRTOSV8.2.1/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/FreeRTOSV8.2.1/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../ThirdParty/FreeRTOSV8.2.1/FreeRTOS/Demo/Common/Minimal/: GenQTest.c PollQ.c QueueSet.c semtest.c
    ../../../ThirdParty/FreeRTOSV8.2.1/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group lwIP
    ../lwip-1.4.1/port/FreeRTOS/: sys_arch.c time_stamp.c
    ../lwip-1.4.1/port/FreeRTOS/netif/: ethernetif.c nuc472_eth.c
    ../../../ThirdParty/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timers_lwip.c udp.c
    ../../../ThirdParty/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../ThirdParty/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../ThirdParty/lwip-1.4.1/src/netif/: etharp.c
