# Keil uVision project Semihost.uvproj, settings and files
target Semihost (ARM-ADS)
  device: NUC472HI8AE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: Semihost
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\Library\Device\Nuvoton\NUC472_442\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\CMSIS\Include
  asm define: DEBUG_ENABLE_SEMIHOST
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_NUC472_442.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    ../../../Library/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
  group Library
    ../../../Library/StdDriver/src/: retarget.c
  group User
    ../: main.c
    ../../../Library/StdDriver/src/: clk.c sys.c
